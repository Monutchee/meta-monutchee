FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://msap1-meter-dma.cfg file://msap1-ptp.cfg"
