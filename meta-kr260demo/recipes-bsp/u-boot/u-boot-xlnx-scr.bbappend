FILESEXTRAPATHS:prepend:kr260demo := "${THISDIR}/u-boot-xlnx-scr:"
