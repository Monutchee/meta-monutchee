FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://modify-kernel-features.cfg"